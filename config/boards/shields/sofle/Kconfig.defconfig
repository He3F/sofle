## config/boards/shields/sofle/Kconfig.defconfig
```kconfig
if SHIELD_SOFLE

config ZMK_KEYBOARD_NAME
    default "mySofle"
    ZMK_USB true

endif
```
